# Keil uVision project swd_downloader.uvprojx, settings and files
target Offline_downloader (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: swd_downloader +hex
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: .\src;.\src\DAP;.\src\CSL;.\src\CSL\CMSIS\CoreSupport;.\src\CSL\CMSIS\DeviceSupport;.\src\CSL\STM32F10x_StdPeriph_Driver;.\src\CSL\STM32_USB-FS-Device_Driver;.\src\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./src/: main.c SWD_host.c SWD_flash.c spi_driver.c usart_driver.c P25Q80.c scheduler.c
    ./src/algo/: NRF52.c
  group DAP
    ./src/DAP/: DAP.c SW_DP.c
software components: CMSIS:CORE 5.1.2, CMSIS Driver:SPI 2.2, CMSIS Driver:USART 2.2, Device:DMA 1.2, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0, Device:StartupConfig 8.15.2
